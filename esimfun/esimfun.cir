* C:\Users\YUVARAJ.N\eSim-Workspace\esimfun\esimfun.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 21:32:31

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SC22  Net-_SC13-Pad2_ Net-_SC22-Pad2_ Net-_SC20-Pad3_ Net-_SC22-Pad4_ Net-_SC20-Pad5_ sky130_stdcells__dfrbp_1
SC23  Net-_SC13-Pad2_ Net-_SC22-Pad4_ Net-_SC20-Pad3_ Net-_SC23-Pad4_ Net-_SC20-Pad5_ sky130_stdcells__dfrbp_1
SC21  Net-_SC13-Pad2_ Net-_SC21-Pad2_ Net-_SC17-Pad3_ Net-_SC21-Pad4_ Net-_SC20-Pad5_ sky130_stdcells__dfrbp_1
SC20  Net-_SC13-Pad2_ Net-_SC20-Pad2_ Net-_SC20-Pad3_ Net-_SC20-Pad4_ Net-_SC20-Pad5_ sky130_stdcells__dfrbp_1
SC14  Net-_SC14-Pad1_ Net-_SC14-Pad2_ sky130_tests__not
SC8  Net-_SC8-Pad1_ ? sky130_tests__not
SC5  Net-_SC5-Pad1_ Net-_SC13-Pad2_ sky130_tests__not
SC6  Net-_SC6-Pad1_ Net-_SC5-Pad1_ Net-_SC17-Pad2_ sky130_stdcells__or2_0
SC7  Net-_SC21-Pad4_ Net-_SC22-Pad2_ Net-_SC7-Pad3_ sky130_stdcells__or2_0
SC31  Net-_SC22-Pad2_ Net-_SC21-Pad4_ ? sky130_stdcells__and2_0
SC30  Net-_SC23-Pad4_ Net-_SC22-Pad4_ Net-_SC27-Pad2_ sky130_stdcells__and2_0
SC27  Net-_SC27-Pad1_ Net-_SC27-Pad2_ sky130_tests__not
SC28  Net-_SC28-Pad1_ Net-_SC28-Pad2_ sky130_tests__not
SC29  Net-_SC28-Pad2_ Net-_SC24-Pad5_ sky130_tests__not
SC24  Net-_SC24-Pad1_ Net-_SC24-Pad1_ Net-_SC24-Pad1_ Net-_SC24-Pad1_ Net-_SC24-Pad5_ sky130_stdcells__and4_1
SC25  Net-_SC20-Pad4_ Net-_SC20-Pad4_ Net-_SC20-Pad4_ Net-_SC20-Pad4_ Net-_SC24-Pad1_ sky130_stdcells__and4_1
SC17  Net-_SC14-Pad1_ Net-_SC17-Pad2_ Net-_SC17-Pad3_ sky130_stdcells__or2_0
U2  Net-_U1-Pad4_ Net-_SC32-Pad3_ ? Net-_U2-Pad4_ Net-_U2-Pad4_ count23
U3  Net-_U2-Pad4_ Net-_SC32-Pad3_ Net-_U14-Pad~_ Net-_U3-Pad4_ Net-_U3-Pad4_ count23
U1  Net-_SC26-Pad3_ Net-_SC32-Pad3_ ? Net-_U1-Pad4_ Net-_U1-Pad4_ count23
SC2  Net-_SC2-Pad1_ Net-_SC1-Pad1_ sky130_tests__not
SC9  Net-_SC15-Pad2_ Net-_SC2-Pad1_ sky130_tests__not
SC15  Net-_SC15-Pad1_ Net-_SC15-Pad2_ sky130_tests__not
SC19  Net-_SC10-Pad2_ Net-_SC15-Pad1_ sky130_tests__not
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ sky130_tests__not
SC10  Net-_SC1-Pad2_ Net-_SC10-Pad2_ sky130_tests__not
SC26  Net-_SC10-Pad2_ Net-_SC13-Pad2_ Net-_SC26-Pad3_ sky130_stdcells__and2_0
scmode1  SKY130mode
SC32  Net-_SC13-Pad2_ Net-_SC14-Pad2_ Net-_SC32-Pad3_ sky130_stdcells__and2_0
U4  Net-_SC7-Pad3_ Net-_SC20-Pad4_ Net-_SC20-Pad2_ xor21
U5  Net-_SC8-Pad1_ Net-_SC6-Pad1_ Net-_SC21-Pad2_ xor21
U9  Net-_SC22-Pad2_ plot_v1
U8  Net-_SC13-Pad2_ plot_v1
U7  Net-_SC14-Pad2_ plot_v1
U10  Net-_SC6-Pad1_ plot_v1
U11  Net-_SC27-Pad1_ plot_v1
U12  Net-_SC28-Pad1_ plot_v1
U13  Net-_SC28-Pad2_ plot_v1
U14  Net-_U14-Pad~_ plot_v1
U15  Net-_SC20-Pad5_ plot_v1
SC12  Net-_SC11-Pad1_ /C1 GND GND sky130_fd_pr__nfet_01v8
SC4  /C1 Net-_SC11-Pad1_ GND GND sky130_fd_pr__nfet_01v8
SC11  Net-_SC11-Pad1_ /C1 Net-_SC11-Pad3_ Net-_SC11-Pad3_ sky130_fd_pr__pfet_01v8
SC3  /C1 ? Net-_SC11-Pad3_ Net-_SC11-Pad3_ sky130_fd_pr__pfet_01v8
v1  Net-_SC11-Pad3_ GND DC
SC13  Net-_SC11-Pad1_ Net-_SC13-Pad2_ sky130_stdcells__clkinvlp_2

.end
